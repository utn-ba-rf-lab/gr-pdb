options:
  parameters:
    generate_options: qt_gui
    id: Quantify_Experience_1_tono
    output_language: python
    title: Cuantificación
  states: {}

blocks:
- name: Amplitud
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Amplitud
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '2'
    value: '1'
    widget: slider
  states: {}
- name: Constante
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,2,1,2
    label: Constante
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '255'
    value: '0'
    widget: slider
  states: {}
- name: Volumen
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,4,1,2
    label: Volumen
    orient: Qt.Horizontal
    start: '0'
    step: '0.025'
    stop: '1'
    value: '0'
    widget: slider
  states: {}
- name: bits
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,1
    label: bits de cuantificaicón
    orient: Qt.Horizontal
    rangeType: int
    start: '3'
    step: '1'
    stop: '16'
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Amplitud
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Volumen
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: pdb_gr_pdb_0
  id: pdb_gr_pdb
  parameters:
    companding_key: ulaw
    constant_a: '87.6'
    constant_u: Constante
    nbits: bits
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: dark blue
    gui_hint: 0,0,4,6
    legend: 'False'
    name: ''
    nconnections: '2'
    size: '512'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    width1: '2'
    ymax: '1.2'
    ymin: '-1.2'
  states: {}

connections:
- [analog_sig_source_x_0, '0', pdb_gr_pdb_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_1, '0']
- [pdb_gr_pdb_0, '0', blocks_null_sink_0, '0']
- [pdb_gr_pdb_0, '1', blocks_multiply_const_vxx_0, '0']
- [pdb_gr_pdb_0, '1', qtgui_time_sink_x_0, '1']
- [pdb_gr_pdb_0, '2', blocks_null_sink_0_0, '0']

metadata:
  file_format: 1
