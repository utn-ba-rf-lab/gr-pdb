options:
  parameters:
    generate_options: qt_gui
    id: Test123
    output_language: python
    title: ytyty
  states: {}

blocks:
- name: Amplitud
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,3,1,2
    label: Amplitud
    start: '0'
    step: 1/(pow(2,15)-1)
    stop: '1'
    value: '1'
  states: {}
- name: bits
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,2
    label: bits
    rangeType: int
    start: '3'
    step: '1'
    stop: '16'
    value: '8'
  states: {}
- name: frq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,3,1,2
    label: frq
    rangeType: int
    start: '0'
    step: '1000'
    stop: '80000'
    value: '32000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Amplitud*2
    freq: '1000'
    offset: '-Amplitud'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Amplitud
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: pdb_gr_pdb_0
  id: pdb_gr_pdb
  parameters:
    companding_key: ulaw
    constant_a: '87.6'
    constant_u: '255'
    nbits: bits
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: qtgui_tab_widget_0@1
    name: '"Linear Process"'
    type: float
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: qtgui_tab_widget_0@4
    name: '"Compressed Proc"'
    type: float
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    alpha1: '0.25'
    autoscale: 'False'
    bins: '42'
    gui_hint: qtgui_tab_widget_0@2
    label1: Muestras
    marker1: '8'
    name: '"Histograma Lineal"'
    size: '1024'
    type: float
    update_time: '1'
    xmax: '1'
    xmin: '-1'
  states: {}
- name: qtgui_histogram_sink_x_0_0_0
  id: qtgui_histogram_sink_x
  parameters:
    alpha1: '0.25'
    autoscale: 'False'
    bins: '42'
    gui_hint: qtgui_tab_widget_0@5
    label1: Muestras
    marker1: '8'
    name: '"Histograma Compressed Proc"'
    size: '1024'
    type: float
    update_time: '1'
    xmax: '1'
    xmin: '-1'
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,3,3
    label0: Tiempo
    label1: Frecuencia (FFT)
    label2: Histograma
    label3: Tiempo
    label4: Frecuencia (FFT)
    label5: Histograma
    num_tabs: '6'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@0
    name: '"Linear"'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2.5'
    ymin: '-2.5'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@3
    name: '"Compressed Proc"'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2.5'
    ymin: '-2.5'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', pdb_gr_pdb_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [pdb_gr_pdb_0, '0', qtgui_freq_sink_x_0, '0']
- [pdb_gr_pdb_0, '0', qtgui_histogram_sink_x_0, '0']
- [pdb_gr_pdb_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [pdb_gr_pdb_0, '1', blocks_null_sink_0, '0']
- [pdb_gr_pdb_0, '2', qtgui_freq_sink_x_0_1, '0']
- [pdb_gr_pdb_0, '2', qtgui_histogram_sink_x_0_0_0, '0']
- [pdb_gr_pdb_0, '2', qtgui_time_sink_x_0_0_0_0, '0']

metadata:
  file_format: 1
