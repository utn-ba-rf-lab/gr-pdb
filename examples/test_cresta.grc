options:
  parameters:
    author: mdoallo
    generate_options: qt_gui
    id: cresta
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Amplitud
  id: variable_qtgui_range
  parameters:
    label: Amplitud
    orient: Qt.Horizontal
    start: '0'
    step: 1/(pow(2,15)-1)
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '128000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Amplitud
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_divide_xx_1
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_max_xx_1
  id: blocks_max_xx
  parameters:
    type: float
    vlen: '128'
    vlen_out: '1'
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.00001'
    type: float
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '128'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    min: '0'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '128'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_divide_xx_1, '0', qtgui_number_sink_0, '0']
- [blocks_max_xx_1, '0', rational_resampler_xxx_0, '0']
- [blocks_rms_xx_0, '0', blocks_divide_xx_1, '1']
- [blocks_rms_xx_0, '0', qtgui_number_sink_0, '1']
- [blocks_stream_to_vector_1, '0', blocks_max_xx_1, '0']
- [blocks_throttle_0, '0', blocks_rms_xx_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '1']
- [rational_resampler_xxx_0, '0', blocks_divide_xx_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
