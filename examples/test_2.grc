options:
  parameters:
    generate_options: qt_gui
    id: Test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Amplitud
  id: variable_qtgui_range
  parameters:
    label: Amplitud
    orient: Qt.Horizontal
    start: '0'
    step: 1/(pow(2,15)-1)
    stop: '1'
    value: '0'
  states: {}
- name: bits
  id: variable_qtgui_range
  parameters:
    label: bits
    orient: Qt.Horizontal
    rangeType: int
    start: '3'
    step: '1'
    stop: '16'
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Amplitud
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: pdb_gr_pdb_0
  id: pdb_gr_pdb
  parameters:
    nbits: bits
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [analog_sig_source_x_0, '0', pdb_gr_pdb_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '1']
- [pdb_gr_pdb_0, '0', audio_sink_0, '0']
- [pdb_gr_pdb_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
