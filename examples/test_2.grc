options:
  parameters:
    generate_options: qt_gui
    id: Test
    output_language: python
    title: 7 bits Quantification
  states: {}

blocks:
- name: bits
  id: variable_qtgui_range
  parameters:
    label: bits
    orient: Qt.Horizontal
    rangeType: int
    start: '4'
    step: '1'
    stop: '16'
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: pdb_gr_pdb_0
  id: pdb_gr_pdb
  parameters:
    companding_key: alaw
    constant_a: '87.6'
    constant_u: '255'
    nbits: bits
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: dark blue
    legend: 'False'
    name: '"7 bits quantification"'
    size: '512'
    srate: samp_rate
    type: float
    width1: '2'
    ymax: '1.2'
    ymin: '-1.2'
  states: {}

connections:
- [analog_sig_source_x_0, '0', pdb_gr_pdb_0, '0']
- [pdb_gr_pdb_0, '0', audio_sink_0, '0']
- [pdb_gr_pdb_0, '0', qtgui_time_sink_x_0, '0']
- [pdb_gr_pdb_0, '1', blocks_null_sink_0, '0']
- [pdb_gr_pdb_0, '2', blocks_null_sink_0_0, '0']

metadata:
  file_format: 1
