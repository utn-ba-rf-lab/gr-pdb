options:
  parameters:
    generate_options: qt_gui
    id: Test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bits
  id: variable_qtgui_range
  parameters:
    label: bits
    orient: Qt.Horizontal
    rangeType: int
    start: '7'
    step: '1'
    stop: '10'
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sample
  id: variable_qtgui_range
  parameters:
    label: sample
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: pdb_gr_pdb_0
  id: pdb_gr_pdb
  parameters:
    nbits: bits
    sample: sample
  states: {}

connections:
- [blocks_null_source_0, '0', pdb_gr_pdb_0, '0']

metadata:
  file_format: 1
