options:
  parameters:
    generate_options: qt_gui
    id: Test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bits
  id: variable_qtgui_range
  parameters:
    label: bits
    rangeType: int
    start: '3'
    step: '1'
    stop: '10'
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sample
  id: variable_qtgui_range
  parameters:
    label: sample
    start: '-1- 1/(pow(2,15)-1)'
    step: 1/(pow(2,15)-1)
    stop: '1'
    value: '0'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: sample
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: pdb_gr_pdb_0
  id: pdb_gr_pdb
  parameters:
    companding_key: ulaw
    constant_a: '87.6'
    constant_u: '255'
    nbits: bits
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', pdb_gr_pdb_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [pdb_gr_pdb_0, '0', qtgui_time_sink_x_0, '0']
- [pdb_gr_pdb_0, '1', blocks_null_sink_0, '0']
- [pdb_gr_pdb_0, '2', blocks_null_sink_0_0, '0']

metadata:
  file_format: 1
