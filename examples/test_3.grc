options:
  parameters:
    generate_options: qt_gui
    id: Test_3
    output_language: python
    realtime_scheduling: '1'
    title: Test 3
  states: {}

blocks:
- name: Frecuencia
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,3
    label: F. de corte
    orient: Qt.Horizontal
    start: '1000'
    step: '100'
    stop: '20000'
    value: '20000'
  states: {}
- name: Ganancia
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,1
    label: Amplitud
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.5'
    widget: slider
  states: {}
- name: bits
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: bits
    orient: Qt.Horizontal
    rangeType: int
    start: '3'
    step: '1'
    stop: '16'
    value: '16'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Ganancia
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/mdoallo/Descargas/El mareo.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: Frecuencia
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '300'
    win: firdes.WIN_HAMMING
  states: {}
- name: pdb_gr_pdb_0
  id: pdb_gr_pdb
  parameters:
    nbits: bits
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: qtgui_tab_widget_0@0
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    alpha1: '0.25'
    autoscale: 'False'
    bins: '42'
    gui_hint: qtgui_tab_widget_0@2
    label1: Muestras
    marker1: '8'
    name: '"Histograma"'
    size: '1024'
    type: float
    update_time: '1'
    xmax: '1'
    xmin: '-1'
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,5,5
    label0: Frecuencia (FFT)
    label1: Tiempo
    label2: Histograma
    num_tabs: '3'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: qtgui_tab_widget_0@1
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', pdb_gr_pdb_0, '0']
- [pdb_gr_pdb_0, '0', blocks_multiply_const_vxx_0, '0']
- [pdb_gr_pdb_0, '0', qtgui_freq_sink_x_0, '0']
- [pdb_gr_pdb_0, '0', qtgui_histogram_sink_x_0, '0']
- [pdb_gr_pdb_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
